# Keil uVision project lcd_dri_v_0.uvprojx, settings and files
target lcd_dri_v_0 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: lcd_dri_v_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;.\sys\delay;.\OutDri;..\Src\h_spi;..\MDK-ARM;..\MDK-ARM;..\zlggui;..\wkup;..\MDK-ARM;..\MALLOC;..\NAND
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
    ./OutDri/: lcd144_dri.c
    ./: music.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: pwm_back.c button.c oled.c power_control.c electr_cure.h e_cure.h e_cure.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c
    ./OutDri/: lcd144_2.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c stm32f4xx_ll_fmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group sys
    ./sys/delay/: delay.c
  group zlggui
    ../zlggui/: font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c windows.c
  group wkup
    ../wkup/: wkup.c
  group MALLOC
    ../MALLOC/: malloc.c
  group NAND_FLASH
    ../NAND/: ftl.c nand.c
software components: CMSIS:CORE 4.3.0
